## linux/opensbi/platform/tinylinuxrv_emu/configs/defconfig
```kconfig
CONFIG_FDT=y
CONFIG_FDT_REGMAP=y
CONFIG_FDT_REGMAP_SYSCON=y
CONFIG_FDT_RESET=y
CONFIG_FDT_RESET_SYSCON=y
```
